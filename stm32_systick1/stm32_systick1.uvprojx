# Keil uVision project stm32_systick1.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32_systick1
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: .\beep;.\core;.\include;.\key;.\led;.\sys
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group src
    ./src/: main.c
  group led
    ./led/: led.c
  group beep
    ./beep/: beep.c
  group key
    ./key/: key.c
  group core
    ./core/: startup_stm32f40_41xxx.s
  group sys
    ./sys/: delay.c misc.c stm32f4xx_gpio.c stm32f4xx_it.c stm32f4xx_rcc.c stm32f4xx_usart.c sys.c system_stm32f4xx.c usart.c
