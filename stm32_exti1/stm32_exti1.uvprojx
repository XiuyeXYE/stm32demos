# Keil uVision project stm32_exti1.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32_exti1 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: .\sys;.\include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group src
    ./src/: main.c exti.c beep.c key.c led.c
  group sys
    ./sys/: misc.c delay.c stm32f4xx_gpio.c stm32f4xx_it.c stm32f4xx_rcc.c stm32f4xx_usart.c sys.c system_stm32f4xx.c usart.c startup_stm32f40_41xxx.s stm32f4xx_exti.c stm32f4xx_syscfg.c
